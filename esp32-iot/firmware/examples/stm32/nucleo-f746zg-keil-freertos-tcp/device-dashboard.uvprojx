# Keil uVision project device-dashboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: device-dashboard
  c flags: Optim=6 OneElfS=1 uC99=1
  c define: STM32F7xx=1 HTTP_URL=\"http://0.0.0.0/\"
  c misc: -W -Wall -Wextra -Wdouble-promotion -Wno-unused-parameter -Wconversion -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-sign-compare -Wno-pragma-pack -Wno-uninitialized -fno-common -fdata-sections
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: hal.h main.c net.c packed_fs.c syscalls.c FreeRTOSIPConfig.h phyHandling.c mongoose.c mongoose_custom.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
target Test (6160000::V6.16::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: as above
  output: firmware +hex
  c flags: Optim=6 OneElfS=1 uC99=1
  c define: STM32F7xx=1 HTTP_URL=\"http://0.0.0.0/\" UART_DEBUG=USART1
  c misc: as above
  c include: .
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, FreeRTOS:FreeRTOS+ TCP:Buffer Allocation 3.1.0, FreeRTOS:FreeRTOS+ TCP:Compiler Port 3.1.0, FreeRTOS:FreeRTOS+ TCP:Core Library 3.1.0, FreeRTOS:FreeRTOS+ TCP:Network Interface 3.1.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:RNG 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5
